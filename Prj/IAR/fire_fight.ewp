# IAR project fire_fight.ewp, settings and files
configuration FX15Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FX15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\App\communication; ..\..\App\Overtake
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_fight.srec
  ILINK.IlinkOutputFile: fire_fight.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60X512.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FN15Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc
  group App
    ../../App/: hardware.c Isr.c main.c MK60_conf.c MK60_it.c note.txt user_define.c
  group App/communication
    ../../App/communication/: communication.c
  group App/Control
    ../../App/Control/: CalError.c MotorCtrl.c RudderCtrl.c
  group App/Drive
    ../../App/Drive/: Eagle.c font.c hardware_init.c oled.c Sccb.c uart.c
  group App/Getline
    ../../App/Getline/: findcross.c findline.c findround.c findstart.c findzhangai.c getline.c
  group App/Inc
    ../../App/Inc/: Control.h Drive.h GetLine.h include.h Isr.h MK60_conf.h MK60_it.h PORT_cfg.h
    ../../App/: hardware.h user_define.h
  group App/Overtake
    ../../App/Overtake/: overtake_round.c overtake_round.h overtake_straight.c overtake_straight.h
  group Chip
    ../../Chip/Src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
    ../../Chip/Src/IAR/: startup_MK60F15.s system_MK60F15.c
  group Inc
    ../../Chip/Inc/: common.h misc.h MK60_adc.h MK60_can.h MK60_dac.h MK60_dma.h MK60_DWT.h MK60_flash.h MK60_flexbus.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_PIT.h MK60_port.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_wdog.h vectors.h
    ../../Chip/Inc/IAR/: iar.h system_MK60F15.h
    ../../Chip/Inc/kinetis/: MK60F15.h
  group Lib/CMSIS
    ../../Lib/CMSIS/Inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
