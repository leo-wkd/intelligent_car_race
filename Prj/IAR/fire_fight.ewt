<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>FX15Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FN15Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <group>
      <name>communication</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\communication\communication.c</name>
      </file>
    </group>
    <group>
      <name>Control</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\Control\CalError.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Control\MotorCtrl.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Control\RudderCtrl.c</name>
      </file>
    </group>
    <group>
      <name>Drive</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\Eagle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\font.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\hardware_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\oled.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\Sccb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Drive\uart.c</name>
      </file>
    </group>
    <group>
      <name>Getline</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\findcross.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\findline.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\findround.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\findstart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\findzhangai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Getline\getline.c</name>
      </file>
    </group>
    <group>
      <name>Inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\Control.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\Drive.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\GetLine.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\hardware.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\include.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\Isr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\MK60_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\MK60_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Inc\PORT_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\user_define.h</name>
      </file>
    </group>
    <group>
      <name>Overtake</name>
      <file>
        <name>$PROJ_DIR$\..\..\App\Overtake\overtake_round.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Overtake\overtake_round.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Overtake\overtake_straight.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\App\Overtake\overtake_straight.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\App\hardware.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\Isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\MK60_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\note.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\App\user_define.c</name>
    </file>
  </group>
  <group>
    <name>Chip</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_DWT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_flexbus.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_ftm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_mcg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_sdhc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_SysTick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\MK60_wdog.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\startup_MK60F15.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\IAR\system_MK60F15.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Src\vectors.c</name>
    </file>
  </group>
  <group>
    <name>Inc</name>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\IAR\iar.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_can.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_dac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_DWT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_flexbus.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_FTM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_gpio_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_lptmr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_mcg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_port.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_sdhc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_SysTick.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\MK60_wdog.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\kinetis\MK60F15.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\IAR\system_MK60F15.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Chip\Inc\vectors.h</name>
    </file>
  </group>
  <group>
    <name>Lib</name>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\arm_common_tables.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\arm_const_structs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\arm_math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cm0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cm0plus.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cm3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cm4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cm4_simd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cmFunc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_cmInstr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_sc000.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Lib\CMSIS\Inc\core_sc300.h</name>
      </file>
    </group>
  </group>
</project>


